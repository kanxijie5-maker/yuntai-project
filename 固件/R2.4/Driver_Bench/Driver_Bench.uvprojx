# Keil uVision project Driver_Bench.uvprojx, settings and files
target Driver_Bench (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.6.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: Driver_Bench +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: GD32F30X_HD,HXTAL_VALUE=8000000
  c misc: --c99 --multibyte_chars --locale=english --preinclude keil/armcc_compat.h
  c include: .;keil\CMSIS;keil\GD32\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\keil\flash.sct
  link misc: --entry=Reset_Handler
  group Application
    ./: board.c board.h main.c bench_report.c foc.c foc.h bench_report.h gl40_cogging_table.h timing.h wave.h
    ./common/: decimal.h
  group Startup
    ./keil/: startup.s flash.sct
    ./keil/GD32/: system_gd32f30x.c
  group GD32 Peripherals
    ./keil/GD32/: gd32f30x_rcu.c gd32f30x_gpio.c gd32f30x_usart.c gd32f30x_adc.c gd32f30x_dma.c gd32f30x_timer.c gd32f30x_fwdgt.c
